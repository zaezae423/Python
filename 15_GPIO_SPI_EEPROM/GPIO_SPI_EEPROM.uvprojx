# Keil uVision project GPIO_SPI_EEPROM.uvprojx, settings and files
target GPIO_SPI_EEPROM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_SPI_EEPROM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM3210X_HD
  c include: .\src;.\Header_all
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./src/: func.c GPIO_OUT.c stm32f10x_it.c system_stm32f10x.c user.c
  group lib
    ./lib/: stm32f10x_lib.lib
